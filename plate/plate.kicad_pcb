File: plate/plate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 285.5 x 76 mm, 0 parts

Commit message: Rename project
Other:
- outline, holes or cut-outs redrawn
